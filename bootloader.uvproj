# Keil uVision project bootloader.uvproj, settings and files
target bootloader (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: bootloader
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o .\build\bin\bootloader.bin .\build\objects\bootloader.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: .\libraries\CMSIS\startup;.\libraries\CMSIS;.\libraries\STM32F10x_StdPeriph_Driver\inc;.\app;.\drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./app/: common.c download.c main.c stm32f10x_it.c upload.c ymodem.c
  group drivers
    ./drivers/: bsp_usart.c
  group cmsis
    ./libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ./libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group stm32_std_periph
    ./libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
